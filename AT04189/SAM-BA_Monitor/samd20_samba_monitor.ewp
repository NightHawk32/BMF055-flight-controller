# IAR project samd20_samba_monitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __SAMD20J18__
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\Atmel; $TOOLKIT_DIR$\inc\Atmel\samd20; $TOOLKIT_DIR$\inc\Atmel\sam20d; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMD20J18__
  OBJCOPY.OOCOutputFile: samd20_samba_monitor.hex
  ILINK.IlinkOutputFile: samd20_samba_monitor.out
  ILINK.IlinkIcfFile: linker\samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: conf_bootloader.h main.c sam_ba_monitor.c sam_ba_monitor.h usart_sam_ba.c usart_sam_ba.h
